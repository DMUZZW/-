# Keil uVision project TEST.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx HSE_VALUE=25000000
  c include: ..\USER;..\HALLIB\Inc;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\32DIDO;..\HARDWARE\AD5676;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\EEPROM\24CXX;..\HARDWARE\EEPROM\IIC;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\HARDWARE\LED;..\HARDWARE\RTC;..\HARDWARE\W5500\Internet;..\HARDWARE\W5500\SPI-W5500;..\HARDWARE\W5500\W5500;..\PROTOCOL;..\IAP;..\HARDWARE\SD;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\MALLOC;..\HARDWARE\MPU;..\HARDWARE\RNG;..\HARDWARE\SHT30
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group HARDWARE
    ../HARDWARE/32DIDO/: 32DIDO.c
    ../HARDWARE/AD5676/: AD5676.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/EEPROM/24CXX/: 24cxx.c
    ../HARDWARE/EEPROM/IIC/: myiic.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/RTC/: RTC.c
    ../HARDWARE/W5500/Internet/: udp_demo.c
    ../HARDWARE/W5500/SPI-W5500/: SPI_W5500.c
    ../HARDWARE/W5500/W5500/: socket.c utility.c w5500.c w5500_conf.c
    ../HARDWARE/SD/: SD.c SD_Test.c
    ../HARDWARE/TIMER/: Timer.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/RNG/: RNG.c
    ../HARDWARE/SHT30/: SHT30.c
    ../HARDWARE/: HardFault.c
  group PROTOCOL
    ../PROTOCOL/: 8AOAI_PROTOCOL.c 32DIDO_PROTOCOL.c define.c DIDOAIAO.c LOT.c Net_Parameter_Setting.c
  group IAP
    ../IAP/: Flash.c IAP.c
    ../HARDWARE/W5500/Internet/: tcp_demo.c
  group FatFs
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/option/: cc936.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
